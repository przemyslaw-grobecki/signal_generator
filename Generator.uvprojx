# Keil uVision project Generator.uvprojx, settings and files
target Generator (6140000::V6.14::ARMCLANG)
  device: MKL05Z32xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFFC00,0x00001000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Generator
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group src
    ./: main.c DAC.c tsi.c buttons.c lcd1602.c i2c.c pit.c
  group inc
    ./: DAC.h tsi.h frdm_bsp.h buttons.h lcd1602.h i2c.h pit.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
